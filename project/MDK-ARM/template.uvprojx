# Keil uVision project template.uvprojx, settings and files
target Platform (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: ../keil-build-viewer.exe
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\..\sourcecode\05_Core;..\..\sourcecode\05_Core\CMSIS\Include;..\..\sourcecode\05_Core\CMSIS\Device\ST\STM32F4xx\Include;..\..\sourcecode\05_Core\STM32F4xx_StdPeriph_Driver\inc;..\..\sourcecode\04_Bsp;..\..\sourcecode\03_Common\mm;..\..\sourcecode\03_Common\utils;..\..\sourcecode\02_Middlewares\uDevice
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../../sourcecode/01_Application/: main.c isr_register.c
  group Middlewares/uDevice/service
    ../../sourcecode/02_Middlewares/uDevice/service/: ud_macros.h ud_delay.c ud_logger.c ud_i2c_bit.c ud_spi_bit.c
  group Middlewares/uDevice/display/src
    ../../sourcecode/02_Middlewares/uDevice/display/core/: ud_display.c
    ../../sourcecode/02_Middlewares/uDevice/display/adapter/: panel_backlight.c panel_i2c.c panel_spi.c
  group Middlewares/uDevice/display/drv
    ../../sourcecode/02_Middlewares/uDevice/display/driver/: ud_fbdev.c ud_st7735.c ud_st7789.c
  group Middlewares/uDevice/display/bsp
    ../../sourcecode/02_Middlewares/uDevice/display/bsp/stm32/: panel_backlight_impl_st.c panel_spi_impl_st.c
  group Middlewares/uDevice/touch/src
    ../../sourcecode/02_Middlewares/uDevice/touch/core/: ud_touch.c
    ../../sourcecode/02_Middlewares/uDevice/touch/adapter/: touchpad_i2c.c touchpad_ctrl.c
  group Middlewares/uDevice/touch/drv
    ../../sourcecode/02_Middlewares/uDevice/touch/driver/: ud_gt9xx.c
  group Middlewares/uDevice/sflash/src
    ../../sourcecode/02_Middlewares/uDevice/sflash/core/: ud_sflash.c
    ../../sourcecode/02_Middlewares/uDevice/sflash/adapter/: flash_spi.c
  group Middlewares/uDevice/sflash/drv
    ../../sourcecode/02_Middlewares/uDevice/sflash/driver/: ud_w25qxx.c
  group Common/mm
    ../../sourcecode/03_Common/mm/: mm.c tlsf.c
  group Common/utils
    ../../sourcecode/03_Common/utils/: debug.c delay.c templ.c
  group Bsp
    ../../sourcecode/04_Bsp/: bsp.c bsp_debug.c bsp_key.c bsp_led.c bsp_sdram.c bsp_tick.c
  group Core/ISR
    ../../sourcecode/05_Core/ISR/: stm32f4xx_it.c
  group Core/Drivers
    ../../sourcecode/05_Core/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Core/CMSIS
    ../../sourcecode/05_Core/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../sourcecode/05_Core/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
