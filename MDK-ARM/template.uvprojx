# Keil uVision project template.uvprojx, settings and files
target Platform (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: keil-build-viewer.exe
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Core\inc;..\USER\01_APP;..\USER\02_MID\EasyLogger\inc;..\USER\02_MID\LVGL;..\USER\02_MID\LVGL\src;..\USER\02_MID\LVGL\examples\porting;..\USER\02_MID\LVGL\demos;..\USER\02_MID\tlsf;..\USER\02_MID\LWTK;..\USER\03_OS\osal;..\USER\03_OS\implementation;..\USER\03_OS\common;..\USER\03_OS\FreeRTOS\include;..\USER\03_OS\FreeRTOS\portable\RVDS\ARM_CM4F;..\USER\04_BSP\wrapper;..\USER\04_BSP\adapter;..\USER\04_BSP\driver;..\USER\04_BSP\linker;..\USER\05_HAL\EDF\widget;..\USER\05_HAL\EDF\board\st;..\USER\05_HAL\EDF\common;..\USER\05_HAL\EDF\core;..\USER\05_HAL\EDF\port;..\USER\UTILITIES
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 01_APP
    ../USER/01_APP/: app_main.c
  group 02_MID/EasyLogger
    ../USER/02_MID/EasyLogger/src/: elog.c elog_utils.c
    ../USER/02_MID/EasyLogger/port/: elog_port.c
  group 02_MID/LVGL/src
    ../USER/02_MID/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../USER/02_MID/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../USER/02_MID/LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../USER/02_MID/LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../USER/02_MID/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../USER/02_MID/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../USER/02_MID/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../USER/02_MID/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../USER/02_MID/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../USER/02_MID/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../USER/02_MID/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../USER/02_MID/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../USER/02_MID/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../USER/02_MID/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../USER/02_MID/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../USER/02_MID/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../USER/02_MID/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../USER/02_MID/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../USER/02_MID/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../USER/02_MID/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../USER/02_MID/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../USER/02_MID/LVGL/src/extra/widgets/led/: lv_led.c
    ../USER/02_MID/LVGL/src/extra/widgets/list/: lv_list.c
    ../USER/02_MID/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../USER/02_MID/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../USER/02_MID/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../USER/02_MID/LVGL/src/extra/widgets/span/: lv_span.c
    ../USER/02_MID/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../USER/02_MID/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../USER/02_MID/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../USER/02_MID/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../USER/02_MID/LVGL/src/extra/widgets/win/: lv_win.c
    ../USER/02_MID/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../USER/02_MID/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../USER/02_MID/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../USER/02_MID/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../USER/02_MID/LVGL/src/extra/: lv_extra.c
  group 02_MID/LVGL/porting
    ../USER/02_MID/LVGL/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
  group 02_MID/LVGL/demos/widgets
    ../USER/02_MID/LVGL/demos/widgets/: lv_demo_widgets.c
    ../USER/02_MID/LVGL/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group 02_MID/LVGL/demos/benchmark
    ../USER/02_MID/LVGL/demos/benchmark/: lv_demo_benchmark.c
    ../USER/02_MID/LVGL/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group 02_MID/tlsf
    ../USER/02_MID/tlsf/: tlsf.c
  group 02_MID/LWTK
    ../USER/02_MID/LWTK/: lw_btn.c lw_ll.c lw_math.c lw_mem.c lw_msg.c lw_queue.c lw_ringbuf.c lw_shell.c lw_timer.c lw_wdg.c
  group 03_OSAL
    ../USER/03_OS/osal/: osal_heap.c osal_mutex.c osal_queue.c osal_sema.c osal_timer.c
  group 03_OS/Implementation
    ../USER/03_OS/implementation/: os_impl_thread.c os_impl_heap.c os_impl_mutex.c os_impl_queue.c os_impl_sema.c os_impl_timer.c
  group 03_OS/Common
    ../USER/03_OS/common/: os_macro.h
  group 03_OS/FreeRTOS
    ../USER/03_OS/FreeRTOS/core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../USER/03_OS/FreeRTOS/portable/MemMang/: heap_4.c
    ../USER/03_OS/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group 04_BSP/Wrapper
    ../USER/04_BSP/wrapper/: bsp_wrapper_light.c bsp_wrapper_display.c bsp_wrapper_touchpad.c bsp_wrapper_sflash.c
  group 04_BSP/Adapter
    ../USER/04_BSP/adapter/: bsp_adapter_led.c bsp_adapter_lcd.c bsp_adapter_st7735.c bsp_adapter_w25q64.c bsp_adapter_gt911.c
  group 04_BSP/Driver
    ../USER/04_BSP/driver/: bsp_driver_led.c bsp_driver_lcd.c bsp_driver_st7735.c bsp_driver_gt911.c bsp_driver_w25q64.c
  group 04_BSP/Linker
    ../USER/04_BSP/linker/: bsp_linker_led.c bsp_linker_lcd.c bsp_linker_st7735.c bsp_linker_gt911.c bsp_linker_w25q64.c
  group 05_HAL/EDF/widget
    ../USER/05_HAL/EDF/widget/: edf_pin.c edf_i2c.c edf_soft_i2c.c edf_usart.c edf_spi.c
  group 05_HAL/EDF/board
    ../USER/05_HAL/EDF/board/st/: st_pin.c st_i2c.c st_spi.c
  group 05_HAL/EDF/common
    ../USER/05_HAL/EDF/common/: edf_avl.c edf_mem.c edf_ringbuf.c edf_str.c edf_list.c
  group 05_HAL/EDF/core
    ../USER/05_HAL/EDF/core/: edf_device.c
  group 05_HAL/EDF/port
    ../USER/05_HAL/EDF/port/: edf_port.c
  group UTILITIES
    ../USER/UTILITIES/: user_conf.h user_macros.h templ.c delay.c debug.c memory_manager.c
  group Core
    ../Core/src/: main.c stm32f4xx_it.c gpio.c usart.c systick.c i2c.c spi.c fmc.c ltdc.c rtc.c dwt.c dma.c dma2d.c
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STD_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
